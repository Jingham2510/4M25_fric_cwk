Commit message: added filter for stable result

File: models/block.urdf (robot description, URDF)
Before this commit: robot block, 1 links, 0 joints
Links:
- link block: geometry collision box size=2 2 0.4; visual box size=2 4 0.4
